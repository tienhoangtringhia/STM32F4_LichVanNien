# Keil uVision project LichVanNien.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LichVanNien
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, HSE_VALUE=8000000,__FPU_PRESENT
  c include: ..\..\STM32F4_LichVanNien;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\LCD_5110;..\Libraries\FATFS;..\Libraries\FATFS\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: main.c stm32f4xx_it.c attributes.h defines.h tm_stm32f4_adc.c tm_stm32f4_adc.h tm_stm32f4_delay.c tm_stm32f4_delay.h tm_stm32f4_ds1307.c tm_stm32f4_ds1307.h tm_stm32f4_fatfs.c tm_stm32f4_fatfs.h tm_stm32f4_fonts.c tm_stm32f4_fonts.h tm_stm32f4_general.c tm_stm32f4_general.h tm_stm32f4_gpio.c tm_stm32f4_gpio.h tm_stm32f4_i2c.c tm_stm32f4_i2c.h tm_stm32f4_pcd8544.c tm_stm32f4_pcd8544.h tm_stm32f4_pwm.c tm_stm32f4_pwm.h tm_stm32f4_rcc.c tm_stm32f4_rcc.h tm_stm32f4_spi.c tm_stm32f4_spi.h tm_stm32f4_spi_dma.c tm_stm32f4_spi_dma.h tm_stm32f4_timer_properties.c tm_stm32f4_timer_properties.h
  group CMSIS
    ../: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group LCD_5110
    ../Libraries/LCD_5110/: tm_stm32f4_pcd8544.c
  group FATFS
    ../Libraries/FATFS/: diskio.c ff.c
